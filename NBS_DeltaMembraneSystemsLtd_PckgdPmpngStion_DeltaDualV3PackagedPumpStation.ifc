Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2024-10-24T14:14:33
Written by: ODA IFC SDK 22.8
Made in: 22.1.70.9 - Exporter 22.4.0.0 - Alternate UI 22.4.0.0

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status
COBie - Category: Project Information

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm
COBie - Category: Project Information

# IfcBuilding
COBie - Category: Project Information

# IfcBuildingStorey: Level:Circle Head - Project Datum, Level 0
LongName: Level 0; Elevation: 0 mm
COBie - Category: Levels; Name: Level 0

# IfcDistributionPort (4)
Description: Flow
Name | FlowDirection
3 x Port_326837 | SINK
Port_326837 | SOURCE

# IfcFlowMovingDevice: NBS_DeltaMembraneSystemsLtd_PckgdPmpngStion_DeltaDualV3PackagedPumpStation:DeltaDualV3PackagedPumpStation, NBS_DeltaMembraneSystemsLtd_PckgdPmpngStion_DeltaDualV3PackagedPumpStation:DeltaDualV3PackagedPumpStation:326837
In: Level 0
Type - Classification: Pr_70_55_76_62 (Uniclass2015); Material: NBS_DeltaMembraneSystemsLtd_HDPE_Yellow (11)
Type - IFC - IfcExportAs: IfcPumpType; IfcExportType: SUBMERSIBLEPUMP
Type - COBie - NominalHeight: 0 mm; NominalLength: 0 mm; NominalWidth: 0 mm; AccessibilityPerformance: n/a; AssetType: Fixed; Category: Pr_70_55_76_62:Packaged pumping stations; Color: n/a; Finish: n/a; Material: High density polyethylene (HDPE); Shape: n/a; Size: n/a; WarrantyDescription: One year; CodePerformance: n/a; Constituents: n/a; Description: Groundwater packaged pump station; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Grade: n/a; Manufacturer: info@deltamembranes.com; ModelNumber: n/a; ModelReference: Delta Dual V3 Packaged Pump Station; Name: PackagedPumpingStations_DeltaDualV3PackagedPumpStation_DeltaMembraneSystemsLtd; ReplacementCost: n/a; SustainabilityPerformance: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - BOS_General - Author: NBS; BIMObjectName: NBS_DeltaMembraneSystemsLtd_PackagedPumpingStations_DeltaDualV3PackagedPumpStation; ManufacturerName: Delta Membrane Systems Ltd; ManufacturerURL: https://www.deltamembranes.com; ProductInformation: https://source.thenbs.com/product/-/2c2c916d-3cc2-d930-ebea-9e8782330422/b152119d-1bbf-44f7-ba10-409d44b5486d; Uniclass2015Code: Pr_70_55_76_62; Uniclass2015Title: Packaged pumping stations; Uniclass2015Version: Products v1.35; Version: 5
Type - NBS_Data - PumpsConfiguration: Twin pumps; Non-returnValve: Required,Not required; ContainsRedListMaterials: No; CountryOfProductManufacture: United Kingdom; Material: High density polyethylene (HDPE); Recyclability: Yes; RecycledContent: 0; IntegralAccessories: Delta Power pack,High level alarm,Textmax telemetry system
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59
